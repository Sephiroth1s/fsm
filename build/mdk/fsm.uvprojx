# Keil uVision project fsm.uvprojx, settings and files
target fsm (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF)  CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: fsm +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xB
  c include: ..\..\platform\SDK\Inc;..\..\platform\SDK\Drivers\STM32F1xx_HAL_Driver\Inc;..\..\platform\SDK\Drivers\STM32F1xx_HAL_Driver\Inc\Legacy;..\..\platform\SDK\Drivers\CMSIS\Device\ST\STM32F1xx\Include;..\..\platform\SDK\Drivers\CMSIS\Include;..\..\platform\utilities\arm;..\..\platform;..\..\platform\critical_sector;..\..\platform\check_string;..\..\platform\event;..\..\platform\mailbox;..\..\platform\print_string
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Application
    ../../: main.c
  group platform
    ../../platform/led/: led.c led.h
    ../../platform/key/: key.c key.h
    ../../platform/uart/: uart.c uart.h
    ../../platform/: platform.c platform.h
    ../../platform/check_string/: check_string.c
    ../../platform/critical_sector/: critical_sector.c
    ../../platform/event/: event.c
    ../../platform/mailbox/: mailbox.c
    ../../platform/print_string/: print_string.c
    ../../platform/queue/: queue.c
  group platform/sdk
    ../../platform/SDK/startup/mdk/: startup_stm32f103xb.s
    ../../platform/SDK/Src/: stm32f1xx_hal_msp.c stm32f1xx_it.c system_stm32f1xx.c
    ../../platform/SDK/Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c
software components: CMSIS:CORE 4.3.0
