# IAR project fsm.ewp, settings and files
configuration fsm (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103C8 ST STM32F103C8
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F103xB
  ICCARM.CCIncludePath2: ../../platform/SDK/Inc; ../../platform/SDK/Drivers/STM32F1xx_HAL_Driver/Inc; ../../platform/SDK/Drivers/STM32F1xx_HAL_Driver/Inc/Legacy; ../../platform/SDK/Drivers/CMSIS/Device/ST/STM32F1xx/Include; ../../platform/SDK/Drivers/CMSIS/Include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: fsm.hex
  ILINK.IlinkOutputFile: fsm.out
  ILINK.IlinkIcfFile: ../../platform/SDK/startup/iar/stm32f103xb_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application
    ../../: main.c
  group platform
    ../../platform/: platform.c
  group platform/key
    ../../platform/key/: key.c key.h
  group platform/led
    ../../platform/led/: led.c led.h
  group platform/SDK
    ../../platform/SDK/Src/: stm32f1xx_hal_msp.c stm32f1xx_it.c
  group platform/SDK/Drivers/CMSIS
    ../../platform/SDK/Src/: system_stm32f1xx.c
  group platform/SDK/Drivers/STM32F1xx_HAL_Driver
    ../../platform/SDK/Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal.c stm32f1xx_hal_cortex.c stm32f1xx_hal_dma.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c
  group platform/SDK/EWARM
    ../../platform/SDK/startup/iar/: startup_stm32f103xb.s
  group platform/uart
    ../../platform/uart/: uart.c uart.h
